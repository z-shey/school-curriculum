# Keil uVision project template2.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template2 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CMSIS;..\interrupt;..\Library;..\list;..\object;..\STARTUP;..\User;..\Library\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../STARTUP/: startup_stm32f10x_hd.s
  group lib
    ../Library/src/: stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_adc.c misc.c
  group cmsis
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group user
    ../User/: stm32f10x_conf.h
    ../interrupt/: stm32f10x_it.c
    ./: main.c
